# Keil uVision project project.uvprojx, settings and files
target rt-thread (6240000::V6.24::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, STM32H7S7xx, __STDC_LIMIT_MACROS, STM32H7RS, __RTTHREAD__, RT_USING_ARMLIBC, USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND
  c include: packages\LVGL-latest\src\widgets\chart;packages\LVGL-latest\src\libs\bin_decoder;libraries\bsp_components;packages\LVGL-latest\src\widgets\lottie;packages\LVGL-latest\src\draw\sw\blend\helium;packages\LVGL-latest\src\libs\gif;packages\LVGL-latest\src\others\xml\parsers;packages\LVGL-latest\src\widgets\buttonmatrix;rt-thread\components\drivers\include;packages\LVGL-latest\src\draw\dma2d;packages\LVGL-latest\src\widgets\spinbox;packages\LVGL-latest\src\drivers\glfw;rt-thread\components\drivers\include;packages\LVGL-latest\src\others\fragment;libraries\CMSIS\Include;packages\LVGL-latest\src\widgets\slider;packages\LVGL-latest\src\libs\ffmpeg;packages\LVGL-latest\src\widgets\imagebutton;packages\LVGL-latest\src\draw\renesas\dave2d;packages\LVGL-latest\src\themes\simple;rt-thread\components\drivers\include;packages\LVGL-latest\src\libs\rle;rt-thread\components\dfs\dfs_v1\include;board\port;rt-thread\components\drivers\include;packages\LVGL-latest\src\drivers\display\lcd;rt-thread\components\drivers\include;packages\LVGL-latest\src\libs\rlottie;packages\LVGL-latest\src\others\xml;packages\LVGL-latest\src\widgets\span;rt-thread\components\libc\posix\io\eventfd;packages\LVGL-latest\src\libs\expat;libraries\CMSIS\Device\ST\STM32H7RSxx\Include;packages\LVGL-latest\src\libs\thorvg\rapidjson\internal;packages\LVGL-latest\src\widgets\property;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\LVGL-latest\src\drivers\display\drm;packages\LVGL-latest\src\libs\bmp;packages\LVGL-latest\src\stdlib\builtin;libraries\STM32H7RSxx_HAL_Driver\Inc;packages\LVGL-latest\src\widgets\tabview;packages\LVGL-latest\src\libs\thorvg;packages\LVGL-latest\src\draw\nxp\pxp;packages\LVGL-latest\src\widgets\image;packages\LVGL-latest\src\themes;packages\LVGL-latest\src\others\file_explorer;packages\LVGL-latest\src\others\monkey;packages\LVGL-latest\src\others\sysmon;packages\LVGL-latest\src\libs\tiny_ttf;packages\LVGL-latest\src\widgets\canvas;packages\LVGL-latest\src\misc;packages\LVGL-latest\src\draw\vg_lite;packages\LVGL-latest\src\widgets\table;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;libraries\drivers\include;packages\LVGL-latest\src\drivers\windows;packages\LVGL-latest\src\widgets\msgbox;packages\LVGL-latest\src\drivers\display\renesas_glcdc;packages\LVGL-latest\src\libs\thorvg\rapidjson;packages\LVGL-latest\src\widgets\spinner;packages\LVGL-latest\env_support\rt-thread;rt-thread\components\libc\compilers\common\include;packages\LVGL-latest\src\drivers\display\fb;.;packages\LVGL-latest\src\font;packages\LVGL-latest\src\widgets\menu;packages\LVGL-latest\src\layouts;applications\lvgl_port;packages\LVGL-latest\src\osal;packages\LVGL-latest\src\widgets\line;packages\LVGL-latest\src\drivers\qnx;packages\LVGL-latest\src\layouts\flex;packages\LVGL-latest\src\libs\freetype;packages\LVGL-latest\src\indev;packages\LVGL-latest\src\widgets\calendar;applications\lvgl_port\demo;packages\LVGL-latest\src\widgets\scale;packages\LVGL-latest\src\stdlib;rt-thread\components\dfs\dfs_v1\filesystems\romfs;packages\LVGL-latest\src\drivers\display\st7789;packages\LVGL-latest\src\libs\qrcode;rt-thread\components\libc\posix\io\poll;packages\LVGL-latest\src\others\snapshot;packages\LVGL-latest\src\display;packages\LVGL-latest\src\drivers\nuttx;packages\LVGL-latest\src\widgets\win;packages\LVGL-latest\src\widgets\animimage;packages\LVGL-latest\src\draw\opengles;packages\LVGL-latest\src\libs\libpng;packages\LVGL-latest\src\tick;packages\LVGL-latest\src\others\imgfont;packages\LVGL-latest\src\widgets\roller;packages\LVGL-latest\src\draw\sw\blend;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;packages\LVGL-latest\src\drivers\display\st7735;packages\LVGL-latest\src\drivers\display\st7796;packages\LVGL-latest\src\core;packages\LVGL-latest\src\draw\nema_gfx;packages\LVGL-latest\src\draw;packages\LVGL-latest\src\draw\nxp\vglite;packages\LVGL-latest\src\widgets\bar;packages\LVGL-latest\src\libs\lz4;packages\LVGL-latest\src\widgets\list;rt-thread\components\finsh;packages\LVGL-latest\src\others\gridnav;board;packages\LVGL-latest\src\widgets\led;packages\LVGL-latest\src\drivers\libinput;packages\LVGL-latest\src;libraries\drivers\include\config;packages\LVGL-latest\src\drivers\display\st_ltdc;packages\LVGL-latest\src\drivers\x11;rt-thread\components\drivers\spi;applications;packages\LVGL-latest\src\themes\mono;rt-thread\components\libc\compilers\common\extension;packages\LVGL-latest\src\widgets\arc;packages\LVGL-latest\src\widgets\textarea;packages\LVGL-latest\src\draw\sw\blend\neon;packages\LVGL-latest\src\drivers\sdl;packages\LVGL-latest\src\libs\fsdrv;packages\LVGL-latest\src\libs\tjpgd;board\CubeMX_Config\Appli\Core\Inc;packages\LVGL-latest\src\draw\sdl;rt-thread\components\drivers\spi\sfud\inc;packages\LVGL-latest\src\libs\libjpeg_turbo;packages\LVGL-latest\src\drivers\evdev;packages\LVGL-latest\src\widgets\label;packages\LVGL-latest\src\widgets\checkbox;packages\LVGL-latest\src\others\font_manager;rt-thread\libcpu\arm\common;packages\LVGL-latest\src\others\vg_lite_tvg;libraries\drivers;packages\LVGL-latest\src\drivers\display\ili9341;packages\LVGL-latest\src\widgets\button;rt-thread\include;packages\LVGL-latest\src\others\observer;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-latest\src\draw\sw\blend\arm2d;packages\LVGL-latest\src\drivers\wayland;rt-thread\components\libc\posix\io\epoll;packages\LVGL-latest\src\libs\lodepng;packages\LVGL-latest\src\drivers\display\tft_espi;packages\LVGL-latest\src\widgets\switch;packages\LVGL-latest\src\widgets\keyboard;packages\LVGL-latest\src\layouts\grid;packages\LVGL-latest\src\libs\barcode;rt-thread\libcpu\arm\cortex-m7;packages\LVGL-latest\src\draw\sw\arm2d;packages\LVGL-latest\src\widgets\objx_templ;packages\LVGL-latest\src\libs\thorvg\rapidjson\error;packages\gt9147-v1.1.0\inc;packages\LVGL-latest\src\widgets\dropdown;packages\LVGL-latest\src\draw\sw;packages\LVGL-latest\src\widgets\tileview;packages\LVGL-latest\src\libs\svg;packages\LVGL-latest\src\themes\default;packages\LVGL-latest\src\others\ime;packages\LVGL-latest\src\misc\cache;packages\LVGL-latest\src\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c photo_capture.c
    applications/ov5640/: camera_preview.c ov5640.c ov5640_reg.c
    applications/mlx90640/: thermal_preview.c mlx90640_port.c MLX90640_API.c
  group TFStorage
    libraries/drivers/: drv_sdmmc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    libraries/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_hal_sd.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/CubeMX_Config/Appli/Core/Src/: stm32h7rsxx_hal_msp.c
    board/: board.c drv_mpu.c
    board/port/: drv_ssd2828.c filesystem.c
    libraries/drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_psram.c drv_soft_i2c.c drv_spi.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh_parse.c cmd.c msh.c msh_file.c
  group gt9147
    packages/gt9147-v1.1.0/src/: gt9147.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group LVGL
    packages/LVGL-latest/src/draw/vg_lite/: lv_vg_lite_stroke.c lv_draw_vg_lite_border.c lv_vg_lite_pending.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_buf_vg_lite.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_math.c lv_draw_vg_lite_line.c lv_vg_lite_path.c lv_draw_vg_lite.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_fill.c lv_vg_lite_utils.c lv_draw_vg_lite_arc.c lv_vg_lite_grad.c
    packages/LVGL-latest/src/font/: lv_font_montserrat_22.c lv_font_montserrat_16.c lv_font_montserrat_24.c lv_font_montserrat_38.c lv_font_montserrat_20.c lv_font_montserrat_44.c lv_font.c lv_font_fmt_txt.c lv_font_montserrat_32.c lv_font_unscii_16.c lv_font_montserrat_46.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_26.c lv_font_unscii_8.c lv_font_montserrat_30.c lv_font_montserrat_18.c lv_font_montserrat_10.c lv_font_montserrat_14.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_montserrat_40.c lv_font_montserrat_28_compressed.c lv_font_montserrat_34.c lv_font_montserrat_12.c lv_font_montserrat_42.c lv_font_montserrat_36.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_binfont_loader.c lv_font_montserrat_28.c
    packages/LVGL-latest/src/others/gridnav/: lv_gridnav.c
    packages/LVGL-latest/src/drivers/windows/: lv_windows_input.c lv_windows_context.c lv_windows_display.c
    packages/LVGL-latest/src/misc/: lv_circle_buf.c lv_matrix.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_palette.c lv_rb.c lv_templ.c lv_timer.c lv_profiler_builtin.c lv_log.c lv_math.c lv_utils.c lv_iter.c lv_ll.c lv_style_gen.c lv_tree.c lv_text.c lv_text_ap.c lv_lru.c lv_anim.c lv_anim_timeline.c lv_style.c lv_area.c lv_array.c lv_async.c
    packages/LVGL-latest/src/widgets/span/: lv_span.c
    packages/LVGL-latest/src/drivers/x11/: lv_x11_input.c lv_x11_display.c
    packages/LVGL-latest/src/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-latest/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    packages/LVGL-latest/src/draw/sw/: lv_draw_sw_transform.c lv_draw_sw_line.c lv_draw_sw_letter.c lv_draw_sw_utils.c lv_draw_sw_vector.c lv_draw_sw_img.c lv_draw_sw.c lv_draw_sw_mask_rect.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_gradient.c lv_draw_sw_fill.c lv_draw_sw_box_shadow.c lv_draw_sw_triangle.c lv_draw_sw_mask.c
    packages/LVGL-latest/src/widgets/label/: lv_label.c
    packages/LVGL-latest/src/osal/: lv_pthread.c lv_mqx.c lv_os.c lv_sdl2.c lv_cmsis_rtos2.c lv_windows.c lv_rtthread.c lv_freertos.c
    packages/LVGL-latest/src/libs/freetype/: lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype.c lv_ftsystem.c
    packages/LVGL-latest/src/others/ime/: lv_ime_pinyin.c
    packages/LVGL-latest/src/themes/: lv_theme.c
    packages/LVGL-latest/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    packages/LVGL-latest/src/draw/nxp/pxp/: lv_pxp_osa.c lv_pxp_utils.c lv_draw_pxp_fill.c lv_draw_pxp.c lv_draw_pxp_img.c lv_pxp_cfg.c lv_draw_buf_pxp.c lv_draw_pxp_layer.c
    packages/LVGL-latest/src/stdlib/clib/: lv_mem_core_clib.c lv_string_clib.c lv_sprintf_clib.c
    packages/LVGL-latest/src/widgets/line/: lv_line.c
    packages/LVGL-latest/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_roller_properties.c lv_label_properties.c lv_slider_properties.c lv_image_properties.c lv_keyboard_properties.c lv_obj_properties.c lv_style_properties.c lv_textarea_properties.c
    packages/LVGL-latest/src/libs/barcode/: lv_barcode.c code128.c
    packages/LVGL-latest/src/stdlib/micropython/: lv_mem_core_micropython.c
    packages/LVGL-latest/src/draw/renesas/dave2d/: lv_draw_dave2d_triangle.c lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_utils.c
    packages/LVGL-latest/src/widgets/calendar/: lv_calendar_chinese.c lv_calendar_header_dropdown.c lv_calendar_header_arrow.c lv_calendar.c
    packages/LVGL-latest/src/draw/dma2d/: lv_draw_dma2d_fill.c lv_draw_dma2d_img.c lv_draw_dma2d.c
    packages/LVGL-latest/src/libs/expat/: xmlparse.c xmlrole.c xmltok_impl.c xmltok_ns.c xmltok.c
    packages/LVGL-latest/src/libs/lodepng/: lodepng.c lv_lodepng.c
    packages/LVGL-latest/src/draw/: lv_draw_arc.c lv_image_decoder.c lv_draw_vector.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_buf.c lv_draw_line.c lv_draw.c lv_draw_label.c lv_draw_image.c
    packages/LVGL-latest/src/drivers/nuttx/: lv_nuttx_image_cache.c lv_nuttx_libuv.c lv_nuttx_touchscreen.c lv_nuttx_lcd.c lv_nuttx_profiler.c lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c
    packages/LVGL-latest/src/others/xml/: lv_xml_component.c lv_xml_parser.c lv_xml_base_types.c lv_xml_style.c lv_xml_utils.c lv_xml.c lv_xml_widget.c
    packages/LVGL-latest/src/drivers/display/st7789/: lv_st7789.c
    packages/LVGL-latest/src/stdlib/rtthread/: lv_sprintf_rtthread.c lv_mem_core_rtthread.c lv_string_rtthread.c
    packages/LVGL-latest/src/libs/bin_decoder/: lv_bin_decoder.c
    packages/LVGL-latest/src/draw/nema_gfx/: lv_draw_nema_gfx_border.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_nema_gfx_path.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c
    packages/LVGL-latest/src/libs/lz4/: lz4.c
    packages/LVGL-latest/src/widgets/table/: lv_table.c
    packages/LVGL-latest/src/drivers/display/st7796/: lv_st7796.c
    packages/LVGL-latest/src/widgets/win/: lv_win.c
    packages/LVGL-latest/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite.c lv_draw_vglite_fill.c lv_draw_buf_vglite.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c lv_draw_vglite_triangle.c lv_draw_vglite_line.c
    packages/LVGL-latest/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    packages/LVGL-latest/src/widgets/textarea/: lv_textarea.c
    packages/LVGL-latest/src/libs/fsdrv/: lv_fs_littlefs.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_memfs.c lv_fs_cbfs.c lv_fs_win32.c lv_fs_stdio.c
    packages/LVGL-latest/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    packages/LVGL-latest/src/layouts/grid/: lv_grid.c
    packages/LVGL-latest/src/indev/: lv_indev.c lv_indev_scroll.c lv_indev_gesture.c
    packages/LVGL-latest/src/others/xml/parsers/: lv_xml_tabview_parser.c lv_xml_slider_parser.c lv_xml_obj_parser.c lv_xml_image_parser.c lv_xml_label_parser.c lv_xml_chart_parser.c lv_xml_button_parser.c
    packages/LVGL-latest/src/draw/sw/blend/: lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend.c
    packages/LVGL-latest/src/themes/default/: lv_theme_default.c
    packages/LVGL-latest/src/libs/rlottie/: lv_rlottie.c
    packages/LVGL-latest/src/others/sysmon/: lv_sysmon.c
    packages/LVGL-latest/src/widgets/tabview/: lv_tabview.c
    packages/LVGL-latest/src/themes/mono/: lv_theme_mono.c
    packages/LVGL-latest/src/widgets/tileview/: lv_tileview.c
    packages/LVGL-latest/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    packages/LVGL-latest/src/stdlib/builtin/: lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_mem_core_builtin.c
    packages/LVGL-latest/src/layouts/flex/: lv_flex.c
    packages/LVGL-latest/src/others/imgfont/: lv_imgfont.c
    packages/LVGL-latest/src/drivers/display/fb/: lv_linux_fbdev.c
    packages/LVGL-latest/src/widgets/canvas/: lv_canvas.c
    packages/LVGL-latest/src/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-latest/src/libs/bmp/: lv_bmp.c
    packages/LVGL-latest/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    packages/LVGL-latest/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    packages/LVGL-latest/src/widgets/scale/: lv_scale.c
    packages/LVGL-latest/src/tick/: lv_tick.c
    packages/LVGL-latest/src/drivers/sdl/: lv_sdl_mousewheel.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_window.c
    packages/LVGL-latest/src/widgets/switch/: lv_switch.c
    packages/LVGL-latest/src/core/: lv_obj_style.c lv_obj_property.c lv_group.c lv_obj.c lv_obj_event.c lv_obj_style_gen.c lv_obj_tree.c lv_obj_draw.c lv_refr.c lv_obj_class.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_scroll.c
    packages/LVGL-latest/src/libs/svg/: lv_svg_parser.c lv_svg.c lv_svg_token.c lv_svg_render.c
    packages/LVGL-latest/src/drivers/glfw/: lv_opengles_driver.c lv_glfw_window.c lv_opengles_debug.c lv_opengles_texture.c
    packages/LVGL-latest/src/others/snapshot/: lv_snapshot.c
    packages/LVGL-latest/src/drivers/display/drm/: lv_linux_drm.c
    packages/LVGL-latest/src/widgets/checkbox/: lv_checkbox.c
    packages/LVGL-latest/src/draw/opengles/: lv_draw_opengles.c
    packages/LVGL-latest/src/others/file_explorer/: lv_file_explorer.c
    packages/LVGL-latest/src/widgets/imagebutton/: lv_imagebutton.c
    packages/LVGL-latest/src/draw/sdl/: lv_draw_sdl.c
    packages/LVGL-latest/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c lv_font_manager_utils.c
    packages/LVGL-latest/src/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-latest/src/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-latest/src/drivers/display/ili9341/: lv_ili9341.c
    packages/LVGL-latest/src/libs/libpng/: lv_libpng.c
    packages/LVGL-latest/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-latest/src/drivers/display/st7735/: lv_st7735.c
    packages/LVGL-latest/src/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-latest/src/drivers/evdev/: lv_evdev.c
    packages/LVGL-latest/src/widgets/list/: lv_list.c
    packages/LVGL-latest/src/widgets/objx_templ/: lv_objx_templ.c
    packages/LVGL-latest/src/: lv_init.c
    packages/LVGL-latest/src/display/: lv_display.c
    packages/LVGL-latest/src/widgets/spinner/: lv_spinner.c
    packages/LVGL-latest/src/themes/simple/: lv_theme_simple.c
    packages/LVGL-latest/src/widgets/slider/: lv_slider.c
    packages/LVGL-latest/src/widgets/animimage/: lv_animimage.c
    packages/LVGL-latest/src/widgets/arc/: lv_arc.c
    packages/LVGL-latest/src/others/vg_lite_tvg/: vg_lite_matrix.c
    packages/LVGL-latest/src/widgets/dropdown/: lv_dropdown.c
    packages/LVGL-latest/src/widgets/bar/: lv_bar.c
    packages/LVGL-latest/src/widgets/led/: lv_led.c
    packages/LVGL-latest/src/stdlib/: lv_mem.c
    packages/LVGL-latest/src/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-latest/src/widgets/button/: lv_button.c
    packages/LVGL-latest/src/widgets/image/: lv_image.c
    packages/LVGL-latest/src/others/monkey/: lv_monkey.c
    packages/LVGL-latest/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    packages/LVGL-latest/src/widgets/chart/: lv_chart.c
    packages/LVGL-latest/src/libs/rle/: lv_rle.c
    packages/LVGL-latest/src/others/observer/: lv_observer.c
    packages/LVGL-latest/src/drivers/qnx/: lv_qnx.c
    packages/LVGL-latest/src/widgets/lottie/: lv_lottie.c
    packages/LVGL-latest/src/layouts/: lv_layout.c
    packages/LVGL-latest/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c
    packages/LVGL-latest/src/widgets/roller/: lv_roller.c
    packages/LVGL-latest/src/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-latest/src/widgets/menu/: lv_menu.c
  group LVGL-demo
    applications/lvgl_port/demo/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_compr_az.c.c lv_font_benchmark_montserrat_16_compr_az.c.c lv_font_benchmark_montserrat_28_compr_az.c.c
    applications/lvgl_port/demo/benchmark/: lv_demo_benchmark.c
    applications/lvgl_port/demo/: lv_demo.c
    applications/lvgl_port/demo/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    applications/lvgl_port/demo/widgets/: lv_demo_widgets.c
  group LVGL-port
    applications/lvgl_port/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-latest/env_support/rt-thread/: lv_rt_thread_port.c
  group STM32_HAL
    libraries/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_usart.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_dma2d.c stm32h7rsxx_hal_dcmipp.c stm32h7rsxx_hal_spi.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_jpeg.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal.c stm32h7rsxx_hal_sram.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_cec.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_uart.c
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7r7xx.s
    libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
